# Keil uVision project f446Vga.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f446Vga
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./: main.cpp main.h draw.cpp draw.h
  group drivers
    ./: comport.c drivers.c drivers.h comport.h
  group vga
    ./: vga.c vga.h vga_char.h
  group isr
    ./: isr.c isr.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Startup 2.6.3
